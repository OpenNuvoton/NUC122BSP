# Keil uVision project ISP_I2C.uvproj, settings and files
target ISP_I2C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC122ZD2AN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ISP_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC122\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC122/Source/: system_NUC122.c
    ../../../../Library/Device/Nuvoton/NUC122/Source/ARM/: startup_NUC122.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c i2c_transfer.c
