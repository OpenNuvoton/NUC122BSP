# IAR project USBD_MassStorage_SDCard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC122AN series Nuvoton NUC122AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC122\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_MassStorage_SDCard.bin
  ILINK.IlinkOutputFile: USBD_MassStorage_SDCard.out
  ILINK.IlinkIcfFile: USBD_MassStorage_SDCard.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC122/Source/IAR/: startup_NUC122.s
    ../../../../Library/Device/Nuvoton/NUC122/Source/: system_NUC122.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c uart.c usbd.c
  group User
    ../: descriptors.c main.c MassStorage.c SDCard.c
