# Keil uVision project MassStorage_DataFlash.uvproj, settings and files
target MassStorage_DataFlash (ARM-ADS)
  device: NUC122SD2AN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MassStorage_DataFlash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC122\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC122.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC122/Source/: system_NUC122.c
    ../../../../Library/Device/Nuvoton/NUC122/Source/ARM/: startup_NUC122.s
  group User
    ../: descriptors.c main.c MassStorage.c DataFlashProg.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c fmc.c clk.c sys.c
